# Keil uVision project PAN3029_PAN3060_DK.uvguix.uvprojx, settings and files
target Simplex (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: pan3029_easy_demo_v2.3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030  USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\Radio\inc;..\Libraries\CMSIS\Include;..\..\(Simplex)PAN3029_PAN3060_DK_V2.3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../: stm32f0xx_it.c
  group Radio
    ../Radio/src/: crc.c pan3029_port.c pan3029_rf.c
  group StdPeriph_Driver
    ../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group User
    ../: delay.c gpio.c main.c spi.c uart.c
